PACKAGE_INSTALL = " \
    linux-examples-stm32mp1-userfs \
    "

