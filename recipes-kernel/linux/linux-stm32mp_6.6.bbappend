FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-SOMLABS-add-riverdi-rvt70hsmnwc00-panel-driver.patch \
	file://0002-SOMLABS-add-swap-p-n-and-enable-burst-mode-in-lontiu.patch \
"

